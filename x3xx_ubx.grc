<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>x3xx_ubx_fp</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>X3xx UBX FP</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>center_freq_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>tab@2:6,0,1,1</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch0_ant</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>gui_hint</key><value>tab@3:1,0,1,2</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>label1</key><value>RX2</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch0_freq</value></param>
<param><key>value</key><value>855e6</value></param>
<param><key>gui_hint</key><value>tab@3:0,0,1,8</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ch0_freq_actual</value></param>
<param><key>block_id</key><value>usrp_source</value></param>
<param><key>function_args</key><value>"0"</value></param>
<param><key>function_name</key><value>get_center_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch0_freq_disp</value></param>
<param><key>value</key><value>ch0_freq_actual</value></param>
<param><key>formatter</key><value>lambda x: "%s Hz" % '{:.2e}'.format(float(x))</value></param>
<param><key>gui_hint</key><value>tab@2:6,1,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch0_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tab@3:0,8,1,2</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch0_label</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:0,1,1,1</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ch0_lo_locked</value></param>
<param><key>block_id</key><value>usrp_source</value></param>
<param><key>function_args</key><value>"'lo_locked',0"</value></param>
<param><key>function_name</key><value>get_sensor</value></param>
<param><key>value</key><value>uhd.sensor_value("", False, "")</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch0_lo_locked_disp</value></param>
<param><key>value</key><value>ch0_lo_locked.to_bool()</value></param>
<param><key>formatter</key><value>lambda x: 'Locked' if x else 'UNLOCKED'</value></param>
<param><key>gui_hint</key><value>tab@2:3,1,1,1</value></param>
<param><key>label</key><value>LOs Locked</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch1_ant</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>gui_hint</key><value>tab@4:1,0,1,2</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>label1</key><value>RX2</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1_freq</value></param>
<param><key>value</key><value>855e6</value></param>
<param><key>gui_hint</key><value>tab@4:0,0,1,8</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ch1_freq_actual</value></param>
<param><key>block_id</key><value>usrp_source</value></param>
<param><key>function_args</key><value>"1"</value></param>
<param><key>function_name</key><value>get_center_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch1_freq_disp</value></param>
<param><key>value</key><value>ch1_freq_actual</value></param>
<param><key>formatter</key><value>lambda x: "%s Hz" % '{:.2e}'.format(float(x))</value></param>
<param><key>gui_hint</key><value>tab@2:6,2,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ch1_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tab@4:0,8,1,2</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch1_label</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@2:0,2,1,1</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ch1_lo_locked</value></param>
<param><key>block_id</key><value>usrp_source</value></param>
<param><key>function_args</key><value>"'lo_locked',1"</value></param>
<param><key>function_name</key><value>get_sensor</value></param>
<param><key>value</key><value>uhd.sensor_value("", False, "")</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>ch1_lo_locked_disp</value></param>
<param><key>value</key><value>ch1_lo_locked.to_bool()</value></param>
<param><key>formatter</key><value>lambda x: 'Locked' if x else 'UNLOCKED'</value></param>
<param><key>gui_hint</key><value>tab@2:3,2,1,1</value></param>
<param><key>label</key><value>LOs Locked</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ckb_lo_offset</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>LO Offset?</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>control_all</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Control All?</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_args</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>device_str</value></param>
<param><key>value</key><value>"addr=192.168.40.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lock_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>tab@2:3,0,1,1</value></param>
<param><key>label</key><value>LOs Locked</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>master_freq</value></param>
<param><key>value</key><value>450e6</value></param>
<param><key>gui_hint</key><value>0,2,1,5</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>master_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>0,8,1,2</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>phase_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>tab@2:1,0,1,1</value></param>
<param><key>label</key><value>Phase Offset (Deg)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>real_rx_freq_ch0</value></param>
<param><key>value</key><value>(master_freq if control_all else ch0_freq)+(samp_rate/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>real_rx_freq_ch1</value></param>
<param><key>value</key><value>(master_freq if control_all else ch1_freq)+(samp_rate/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>stddev_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>tab@2:2,0,1,1</value></param>
<param><key>label</key><value>Standard Deviation (Deg)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subdev_spec</value></param>
<param><key>value</key><value>"A:0 B:0"</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(samp_rate/30)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>comment</key><value>Calculate the relative phase offset</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Convert radians to degrees</value></param>
<param><key>const</key><value>57.296</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>ch0_freq_sink_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>master_freq if control_all else ch0_freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0:3,0,1,10</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Channel 0"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>ch1_freq_sink_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>master_freq if control_all else ch1_freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0:3,10,1,10</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Channel 1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>GUI Tab: 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>GUI Tab: 0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0_0_0</value></param>
<param><key>note</key><value>GUI Tab: 3</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0_0_0_0</value></param>
<param><key>note</key><value>GUI Tab: 4</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1</value></param>
<param><key>note</key><value>Status Tab</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>comment</key><value>Phase Offset</value></param>
<param><key>gui_hint</key><value>tab@2:1,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>"Ch0 vs Ch1"</value></param>
<param><key>unit1</key><value>" "</value></param>
<param><key>max</key><value>180</value></param>
<param><key>min</key><value>-180</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>comment</key><value>Standard Deviation</value></param>
<param><key>gui_hint</key><value>tab@2:2,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>"Ch0 vs Ch1"</value></param>
<param><key>unit1</key><value>" "</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>-10</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>real_rx_freq_ch0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>tab@4:3,0,1,10</value></param>
<param><key>name</key><value>"Channel 1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_3</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>real_rx_freq_ch0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>gui_hint</key><value>tab@3:3,0,1,10</value></param>
<param><key>name</key><value>"Channel 0"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>CH0 - Real</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>CH0 - Img</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>CH1 - Real</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>label4</key><value>CH1 - Img</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2:1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Phase Offset 0 vs 1"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>180</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@2:8,0,1,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Ch 0 vs 1</value></param>
<param><key>name</key><value>"Phase Offsets"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>"Degrees"</value></param>
<param><key>ymax</key><value>300</value></param>
<param><key>ymin</key><value>-300</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>std_dev</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.sync_block):
    def __init__(self):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Std Dev',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

    def work(self, input_items, output_items):
        output_items[0][:] = np.std(input_items[0])
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>3,0,1,10</value></param>
<param><key>label0</key><value>Frequency</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>label2</key><value>Phase / Status</value></param>
<param><key>label3</key><value>Channel 0</value></param>
<param><key>label4</key><value>Channel 1</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>ant0</key><value>ch0_ant</value></param>
<param><key>center_freq0</key><value>real_rx_freq_ch0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>master_gain if control_all else ch0_gain</value></param>
<param><key>ant1</key><value>ch1_ant</value></param>
<param><key>center_freq1</key><value>real_rx_freq_ch1</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>master_gain if control_all else ch1_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>device_str</value></param>
<param><key>dev_args</key><value>device_args</value></param>
<param><key>sd_spec0</key><value>subdev_spec</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>ch0_ch1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_ch0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_ch1</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>ch0_ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>ch0_ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_0_0</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_0_0_0</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_0_1</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_0_1_0_0</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_1</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_1_0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_2</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_ch0_2_0_0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>std_dev</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>virtual_sink_ch0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>virtual_sink_ch1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>std_dev</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_0_1</source_block_id><sink_block_id>ch1_freq_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_0_1_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_2</source_block_id><sink_block_id>ch0_freq_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_ch0_2_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
