<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>e310_wbfm_tx</value></param>
<param><key>category</key><value>RDS</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_max_dev</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outbuffer</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>19e3*20</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>input_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>pilot_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>input_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>wavfile</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>88.5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>gr_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>gr_frequency_modulator_fc_0</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>sensitivity</key><value>2*math.pi*fm_max_dev/usrp_rate</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>38e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>usrp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>19e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>usrp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>samp_rate</key><value>usrp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>samp_rate</key><value>usrp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pilot_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.09</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>48</value></param>
<param><key>interp</key><value>380</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>48</value></param>
<param><key>interp</key><value>380</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>38</value></param>
<param><key>interp</key><value>100</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stereo_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wavfile</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_1</source_block_id><sink_block_id>gr_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_frequency_modulator_fc_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
