<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>record_button</value></param>
<param><key>author</key><value>Michael Morrison</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Push the button to record</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>Record Button</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>but_rec</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>but_label</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>comment</key><value>Use Python to create unique filenames
based on time/freq/sample rate.

The only reason I didn't parameterize
this was so that I didn't have to import
datetime into all my other flowgraphs.</value></param>
<param><key>value</key><value>datetime.now().strftime("%Y.%m.%d.%H.%M.%S")+"_"+str(tuned_frequency)+"_"+str(samples_per_second)+".dat"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>filepath</value></param>
<param><key>value</key><value>prefix + filename</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Filepath</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>comment</key><value>Thanks Nate Temple for the if/then trick.</value></param>
<param><key>file</key><value>filepath if but_rec else "/dev/null"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>but_label</value></param>
<param><key>label</key><value>Label</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'Record'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>datestring</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Date Format</value></param>
<param><key>value</key><value>datetime.now().strftime("%Y.%m.%d.%H.%M.%S")</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>comment</key><value>Enter your default folder.</value></param>
<param><key>label</key><value>Default Prefix</value></param>
<param><key>value</key><value>"/home/username/recordings/push_button/"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples_per_second</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tuned_frequency</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>freq_rx</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
