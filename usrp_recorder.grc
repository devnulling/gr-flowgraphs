options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: usrp_recorder
    output_language: python
    run_options: run
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    start: 70e6
    step: 1e3
    stop: 6e9
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '0'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/home/user/captures/"'
  states: {}
- name: recording_checkbox
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Record
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: prefix + datetime.now().strftime("%Y-%m-%d_%H-%M-%S") + "_F" + str(int(freq)) +".fc32" if recording_checkbox else "/dev/null"
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: prefix + datetime.now().strftime("%Y-%m-%d_%H-%M-%S") + "_F" + str(int(freq)) +".sc16" if recording_checkbox else "/dev/null"
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dev_args: '"num_recv_frames=1024,recv_frame_size=512"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_file_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: v3.9.5.0-62-gf520c346
